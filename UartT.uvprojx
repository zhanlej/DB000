# Keil uVision project UartT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UartT +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,DEBUG_ENABLE_SEMIHOST
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\MCULIB;.\MQTT;.\GSM;.\JSON;.\SYSTEM;.\User\RTC;.\User\ws2812;.\User\KEY;.\User\STMFLASH;.\User\buzzer;.\User\DSHCHO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_flash.c
  group User
    ./User/: main.c stm32f10x_it.c aqi.c
    ./User/RTC/: rtc.c
    ./User/ws2812/: WS2812B.c WS2812BNOP.c
    ./User/KEY/: key.c
    ./User/STMFLASH/: stmflash.c
    ./User/buzzer/: buzzer.c
    ./User/DSHCHO/: DSHCHO.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group MCULIB
    ./MCULIB/: MyFiFo.c
  group MQTT
    ./MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group GSM
    ./GSM/: interface.c serialportAPI.c stringAPIext.c sim800C.c uart1.c
  group JSON
    ./JSON/: cJSON.c myJSON.c
  group SYSTEM
    ./SYSTEM/: delay.c sys.c
